<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\Library\CMSIS\Include\arm_common_tables.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Library\CMSIS\Include\arm_const_structs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Library\CMSIS\Include\arm_math.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Library\CMSIS\Include\core_cm0.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Library\CMSIS\Include\core_cm0plus.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Library\CMSIS\Include\core_cm3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Library\CMSIS\Include\core_cm4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Library\CMSIS\Include\core_cm7.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Library\CMSIS\Include\core_cmFunc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Library\CMSIS\Include\core_cmInstr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Library\CMSIS\Include\core_cmSimd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Library\CMSIS\Include\core_sc000.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Library\CMSIS\Include\core_sc300.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Library\CMSIS\stm32f4xx.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Library\CMSIS\system_stm32f4xx.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\Library\CMSIS\startup_stm32f411xe.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Library\CMSIS\system_stm32f4xx.c</name>
    </file>
  </group>
  <group>
    <name>Library</name>
    <group>
      <name>gpio</name>
      <group>
        <name>inc</name>
        <file>
          <name>$PROJ_DIR$\Library\STM32F4xx_StdPeriph_Driver\inc\stm32f4xx_gpio.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\Library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>rcc</name>
      <group>
        <name>inc</name>
        <file>
          <name>$PROJ_DIR$\Library\STM32F4xx_StdPeriph_Driver\inc\stm32f4xx_rcc.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\Library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\User\inc\LED_Con.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\User\main.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\User\inc\stm32f4xx_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\User\inc\stm32f4xx_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\User\inc\stm32f4xx_hal_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\User\inc\stm32f4xx_it.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Ref\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\STM32F4xx_StdPeriph_Driver\inc\stm32f4xx_wwdg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\User\inc\USART.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\User\inc\USART_Data.h</name>
      </file>
    </group>
    <group>
      <name>ISR</name>
      <file>
        <name>$PROJ_DIR$\User\ISR\stm32f4xx_it.c</name>
      </file>
    </group>
    <group>
      <name>LED</name>
      <file>
        <name>$PROJ_DIR$\User\LED_Control\LED_Con.c</name>
      </file>
    </group>
    <group>
      <name>USART</name>
      <file>
        <name>$PROJ_DIR$\User\USART\stm32f4xx_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\User\USART\USART.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\User\USART\USART_Data.c</name>
      </file>
    </group>
    <group>
      <name>WWDG</name>
      <file>
        <name>$PROJ_DIR$\User\WWDG\stm32f4xx_wwdg.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\User\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\User\misc.c</name>
    </file>
  </group>
</project>


