# IAR project DustSensor_NIDS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F412xG; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: D:\01_Work\90_IARProject\DustSensor_NIDS\Library\STM32F4xx_StdPeriph_Driver\inc; D:\01_Work\90_IARProject\DustSensor_NIDS\Library\STM32F4xx_StdPeriph_Driver\src; D:\01_Work\90_IARProject\DustSensor_NIDS\Library\CMSIS; D:\01_Work\90_IARProject\DustSensor_NIDS\Library\CMSIS\Include; D:\01_Work\90_IARProject\DustSensor_NIDS\User; D:\01_Work\90_IARProject\DustSensor_NIDS\User\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DustSensor_NIDS.bin
  ILINK.IlinkOutputFile: DustSensor_NIDS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    Library/CMSIS/: startup_stm32f411xe.s system_stm32f4xx.c
  group CMSIS/inc
    Library/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
    Library/CMSIS/: stm32f4xx.h system_stm32f4xx.h
  group Library/gpio/inc
    Library/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_gpio.h
  group Library/gpio/src
    Library/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c
  group Library/rcc/inc
    Library/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_rcc.h
  group Library/rcc/src
    Library/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c
  group User
    User/: main.c misc.c
  group User/inc
    User/inc/: LED_Con.h stm32f4xx_conf.h stm32f4xx_exti.h stm32f4xx_it.h USART.h USART_Data.h
    User/: main.h
    ../Ref/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_wwdg.h
  group User/ISR
    User/ISR/: stm32f4xx_it.c
  group User/LED
    User/LED_Control/: LED_Con.c
  group User/USART
    User/USART/: stm32f4xx_usart.c USART.c USART_Data.c
  group User/WWDG
    User/WWDG/: stm32f4xx_wwdg.c
